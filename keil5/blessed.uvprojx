# Keil uVision project blessed.uvprojx, settings and files
target blessed_nRF52832_xxaa (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blessed
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CUSTOM_BOARD_INC=yj16002 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\include;..\platform\nRF52832;..\platform\yj16002;..\stack;..\ugfx_2.8;..\ugfx_2.8\src;..\ugfx_2.8\gdisp;..\ugfx_2.8\drivers\gdisp\ST7735;..\..\nRF5_SDK_15.0.0_a53641a\components\drivers_nrf\common;..\..\nRF5_SDK_15.0.0_a53641a\components\drivers_nrf\uart;..\..\nRF5_SDK_15.0.0_a53641a\components\drivers_nrf\nrf_soc_nosd;..\..\nRF5_SDK_15.0.0_a53641a\components\libraries\bsp;..\..\nRF5_SDK_15.0.0_a53641a\components\libraries\util;..\..\nRF5_SDK_15.0.0_a53641a\components\libraries\uart;..\..\nRF5_SDK_15.0.0_a53641a\components\libraries\fifo;..\..\nRF5_SDK_15.0.0_a53641a\components\libraries\gpiote;..\..\nRF5_SDK_15.0.0_a53641a\components\libraries\experimental_log;..\..\nRF5_SDK_15.0.0_a53641a\components\libraries\experimental_log\src;..\..\nRF5_SDK_15.0.0_a53641a\components\libraries\experimental_section_vars;..\..\nRF5_SDK_15.0.0_a53641a\components\libraries\experimental_memobj;..\..\nRF5_SDK_15.0.0_a53641a\components\libraries\strerror;..\..\nRF5_SDK_15.0.0_a53641a\components\libraries\balloc;..\..\nRF5_SDK_15.0.0_a53641a\components\boards;..\..\nRF5_SDK_15.0.0_a53641a\modules\nrfx;..\..\nRF5_SDK_15.0.0_a53641a\modules\nrfx\hal;..\..\nRF5_SDK_15.0.0_a53641a\modules\nrfx\mdk;..\..\nRF5_SDK_15.0.0_a53641a\modules\nrfx\drivers\src;..\..\nRF5_SDK_15.0.0_a53641a\modules\nrfx\drivers\src\prs;..\..\nRF5_SDK_15.0.0_a53641a\modules\nrfx\drivers\include;..\..\nRF5_SDK_15.0.0_a53641a\integration\nrfx;..\..\nRF5_SDK_15.0.0_a53641a\integration\nrfx\legacy;..\..\nRF5_SDK_15.0.0_a53641a\external\fprintf;..\..\nRF5_SDK_15.0.0_a53641a\components\libraries\atomic
  asm define: CUSTOM_BOARD_INC BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DCUSTOM_BOARD_INC,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group board
    ../../nRF5_SDK_15.0.0_a53641a/components/boards/: boards.c
    ../platform/nRF52832/: sdk_config.h
  group platform
    ../platform/nRF52832/: delay.c evtloop.c ll-plat.c log.c radio.c random.c timer.c
    ../../nRF5_SDK_15.0.0_a53641a/integration/nrfx/legacy/: nrf_drv_spi.c
  group stack
    ../stack/: bci.c
  group nRF_libs
    ../stack/: ll.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/uart/: app_uart.c
    ../../nRF5_SDK_15.0.0_a53641a/modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c nrfx_spi.c nrfx_timer.c
    ../../nRF5_SDK_15.0.0_a53641a/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../nRF5_SDK_15.0.0_a53641a/integration/nrfx/legacy/: nrf_drv_uart.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/experimental_log/src/: nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c nrf_log_backend_uart.c nrf_log_backend_serial.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/atomic/: nrf_atomic.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/experimental_memobj/: nrf_memobj.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/balloc/: nrf_balloc.c
    ../../nRF5_SDK_15.0.0_a53641a/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../nRF5_SDK_15.0.0_a53641a/components/libraries/util/: app_util_platform.c app_error.c app_error_weak.c
  group ugfx
    ../ugfx_2.8/src/: gfx.c
    ../ugfx_2.8/src/gdisp/: gdisp.c gdisp_fonts.c gdisp_image.c gdisp_image_bmp.c gdisp_image_gif.c gdisp_image_jpg.c gdisp_image_native.c gdisp_image_png.c gdisp_pixmap.c
    ../ugfx_2.8/src/gdisp/mcufont/: mf_font.c mf_justify.c mf_rlefont.c mf_scaledfont.c mf_bwfont.c mf_encoding.c
    ../ugfx_2.8/drivers/gdisp/ST7735/: gdisp_lld_ST7735.c
    ../ugfx_2.8/src/gdriver/: gdriver.c
    ../ugfx_2.8/src/gos/: gos_x_heap.c gos_x_threads.c gos_raw32.c
    ../ugfx_2.8/boards/base/nRF52832-uj16002/: nrf52832_raw32_ufgx.c
    ../ugfx_2.8/: gfxconf.h
  group ll-scanner
    ../examples/ll-scanner/: main.c
  group bci-ibeacon
    ../examples/bci-ibeacon/: main.c
  group ugfx-st7735
    ../examples/ugfx-st7735/: main.c
software components: CMSIS:CORE 5.1.2, Device:Startup 8.16.0
